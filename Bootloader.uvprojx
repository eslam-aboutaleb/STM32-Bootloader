# Keil uVision project Bootloader.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: BL_prog.c BL_Services.c COM.c DBG_MCU.c Flash.c GPIO_prog.c Led.c main_SupportFuncs.c RCC_program.c SW.c SysTick.c USART_program.c BIT_MATH.h BL_interface.h BL_Services.h COM.h DBG_MCU_interface.h DBG_MCU_private.h Flash_interface.h Flash_private.h GPIO_interface.h GPIO_private.h Led_interface.h Led_Port.h main_SupportFuncs.h RCC_interface.h RCC_private.h SCB_interface.h SCB_private.h STD_TYPES.h SW.h SysTick_interface.h SysTick_private.h UART_private.h USART_interface.h Bootloader.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
